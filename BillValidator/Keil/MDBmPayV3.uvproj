# Keil uVision project MDBmPayV3.uvproj, settings and files
target MDBmPay (ARM-ADS)
  device: LPC1225/321 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x13FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: MDBmPayV3 +hex
  c include: ..\Source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x14000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group StartUp
    ../Source/: startup_LPC12xx.s
  group User
    ../Source/: Main.c LedTask.c MdbSlaveTask.c ComHostTask.c BillValidator.c RTX_Conf_CM.c Time.c Uart.c
  group Lpc_lib
    ../Source/: lpc12xx_gpio.c lpc12xx_iocon.c lpc12xx_libcfg_default.c lpc12xx_sysctrl.c lpc12xx_timer32.c lpc12xx_uart.c
  group CMSIS
    ../Source/: system_LPC12xx.c
